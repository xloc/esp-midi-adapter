## sdkconfig.defaults
```kconfig
# BT config - from official bleprph example
CONFIG_BT_ENABLED=y
CONFIG_BT_NIMBLE_ENABLED=y
CONFIG_BT_BLUEDROID_ENABLED=n
```
